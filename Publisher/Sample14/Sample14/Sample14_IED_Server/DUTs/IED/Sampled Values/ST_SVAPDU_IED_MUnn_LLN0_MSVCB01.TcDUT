(* SV APDU data type (TwinCAT PLC little endian host byte order) *)
TYPE ST_SVAPDU_IED_MUnn_LLN0_MSVCB01 : 
STRUCT
	Asdu1: ST_SVASDU_IED_MUnn_LLN0_MSVCB01; (* SV ASDU *)
END_STRUCT
END_TYPE
