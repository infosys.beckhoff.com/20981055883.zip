PROGRAM P_IEC61850SV01
VAR
END_VAR

IF NOT fbIEDCriticalSection.Enter() THEN
	RETURN;
END_IF

fbIED_MUnn_MSVCB01SvSubscriber();

fbIEDCriticalSection.Leave();

END_PROGRAM
