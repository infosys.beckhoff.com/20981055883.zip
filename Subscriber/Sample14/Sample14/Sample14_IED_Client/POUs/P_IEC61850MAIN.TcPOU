PROGRAM P_IEC61850MAIN
VAR
END_VAR

IF NOT fbIEDCriticalSection.Enter() THEN
	RETURN;
END_IF

fbIEDClient();

fbIEDCriticalSection.Leave();

END_PROGRAM
