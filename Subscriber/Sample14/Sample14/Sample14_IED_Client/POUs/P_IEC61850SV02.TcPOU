PROGRAM P_IEC61850SV02
VAR
END_VAR

IF NOT fbIEDCriticalSection.Enter() THEN
	RETURN;
END_IF

fbIED_MUnn_MSVCB02SvSubscriber();

fbIEDCriticalSection.Leave();

END_PROGRAM
